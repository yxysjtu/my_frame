# Keil uVision project helloworld.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: helloworld +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD
  c misc: --C99 --CPP11
  c include: ..\lib\SYSTEM;..\lib\SYSTEM\timer_lib;..\lib\DEVICE\LED;..\lib\DEVICE\TPAD;..\lib\DEVICE\SERVO;..\lib\DEVICE\BEEP;..\lib\COMMUNICATION\UART;..\lib\DEVICE\KEY
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: startup_stm32f10x_hd.s
  group USER
    ./: main.cpp
  group SYSTEM
    ../lib/SYSTEM/: sys.c basic.cpp exti.cpp wdg.cpp dma.cpp timer.cpp debug.h
    ../lib/SYSTEM/timer_lib/: pwm.cpp pulse.cpp spwm.h tone.h
  group DEVICE
    ../lib/DEVICE/BEEP/: beep.cpp
    ../lib/DEVICE/LED/: led.cpp
    ../lib/DEVICE/KEY/: key.cpp
    ../lib/DEVICE/TPAD/: tpad.cpp
    ../lib/DEVICE/SERVO/: servo.cpp
  group COMMUNICATION
    ../lib/COMMUNICATION/UART/: usart.cpp
